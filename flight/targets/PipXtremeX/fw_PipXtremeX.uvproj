# Keil uVision project fw_PipXtremeX.uvproj, settings and files
target fw_pipxtremex (ARM-GNU)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: fw_pipxtremex
  AfterMake: build.bat
  group src
    ./: main-fake.c build.bat
