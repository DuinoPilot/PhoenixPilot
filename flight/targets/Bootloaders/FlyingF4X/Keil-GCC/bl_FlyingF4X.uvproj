# Keil uVision project bl_FlyingF4X.uvproj, settings and files
target bl_FlyingF4X (ARM-GNU)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: bl_FlyingF4X
  group src
    ../: main.c op_dfu.c pios_board.c pios_usb_board_data.c
  group Config
    ./: link.txt defs.txt
    ../inc/: pios_usb_board_data.h common.h op_dfu.h pios_config.h
    ../../../board_hw_defs/flyingf4x/: board_hw_defs.c
    ../../../../PiOS/Boards/: STM32F4xx_FlyingF4X.h
  group PIOS
    ../../../../PiOS/STM32F4xx/: pios_adc.c pios_bl_helper.c pios_debug.c pios_delay.c pios_dsm.c pios_exti.c pios_flash_internal.c pios_gpio.c pios_i2c.c pios_iap.c pios_irq.c pios_led.c pios_overo.c pios_ppm.c pios_pwm.c pios_rtc.c pios_servo.c pios_spi.c pios_sys.c pios_tim.c pios_usart.c pios_usb.c pios_usb_cdc.c pios_usb_hid.c pios_usbhook.c pios_wdg.c startup.c vectors_stm32f4xx.c
  group Common
    ../../../../PiOS/Common/: pios_board_info.c pios_com_msg.c printf-stdarg.c pios_usb_desc_hid_only.c pios_usb_util.c
  group STM32F4xx
    ../../../../PiOS/STM32F4xx/Libraries/CMSIS3/Device/ST/STM32F4xx/Source/flyingf4x/: system_stm32f4xx.c
    ../../../../PiOS/STM32F4xx/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group STM32 USB
    ../../../../PiOS/STM32F4xx/Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../../../../PiOS/STM32F4xx/Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
