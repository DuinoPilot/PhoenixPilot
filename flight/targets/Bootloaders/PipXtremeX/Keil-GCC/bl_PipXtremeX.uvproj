# Keil uVision project bl_PipXtremeX.uvproj, settings and files
target bl_PipXtremeX (ARM-GNU)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: bl_PipXtremeX
  group src
    ../: main.c op_dfu.c pios_board.c pios_usb_board_data.c
  group Config
    ./: link.txt defs.txt
    ../inc/: pios_usb_board_data.h common.h op_dfu.h pios_config.h
    ../../../board_hw_defs/pipxtremeX/: board_hw_defs.c
    ../../../../PiOS/Boards/: STM32103CB_PIPXTREMEX_Rev1.h
    ../../../../PiOS/STM32F10x/: link_STM32103CB_PIPXTREMEX_memory.ld link_STM32103CB_PIPXTREMEX_BL_sections.ld
  group PIOS
    ../../../../PiOS/STM32F10x/: pios_sys.c pios_led.c pios_delay.c pios_usart.c pios_irq.c pios_debug.c pios_gpio.c pios_iap.c pios_bl_helper.c pios_usb.c pios_usbhook.c pios_usb_hid.c pios_usb_hid_istr.c pios_usb_hid_pwr.c
  group Common
    ../../../../PiOS/Common/: pios_usb_desc_hid_only.c pios_usb_util.c pios_board_info.c pios_com_msg.c printf-stdarg.c
    ../../../../Libraries/: fifo_buffer.c
  group STM32F10X
    ../../../../PiOS/STM32F10x/: startup_stm32f10x_MD_PX.S
    ../../../../PiOS/STM32F10x/Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ../../../../PiOS/STM32F10x/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_dbgmcu.c misc.c
  group STM32F10X USB
    ../../../../PiOS/STM32F10x/Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
