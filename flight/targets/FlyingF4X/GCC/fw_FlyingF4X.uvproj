# Keil uVision project fw_FlyingF4X.uvproj, settings and files
target fw_FlyingF4X (ARM-GNU)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: fw_FlyingF4X
  group src
    ../System/: flyingf4x.c pios_board.c pios_usb_board_data.c
  group FreeRTOS
    ../../../PiOS/Common/Libraries/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../PiOS/Common/Libraries/msheap/: msheap.c pios_msheap.c
    ../../../PiOS/STM32F4xx/Libraries/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group Modules
    ../../../Modules/Sensors/: sensors.c
    ../../../Modules/Attitude/revolution/: attitude.c
    ../../../Modules/Actuator/: actuator.c
    ../../../Modules/ManualControl/: manualcontrol.c
    ../../../Modules/Stabilization/: relay_tuning.c stabilization.c virtualflybar.c
    ../../../Modules/FirmwareIAP/: firmwareiap.c
    ../../../Modules/PathPlanner/: pathplanner.c
    ../../../Modules/Telemetry/: telemetry.c
    ../../../Modules/GPS/: GPS.c NMEA.c UBX.c
    ../../../Modules/AltitudeHold/: altitudehold.c
    ../../../Modules/VtolPathFollower/: vtolpathfollower.c
    ../../../Modules/FixedWingPathFollower/: fixedwingpathfollower.c
    ../../../Modules/CameraStab/: camerastab.c
    ../../../Modules/Autotune/: autotune.c
    ../../../Modules/TxPID/: txpid.c
    ../../../Modules/System/: systemmod.c
  group Libraries
    ../../../Libraries/: alarms.c CoordinateConversions.c paths.c fifo_buffer.c WorldMagModel.c insgps13state.c taskmonitor.c sanitycheck.c
    ../../../Libraries/math/: sin_lookup.c misc_math.c pid.c
  group UAVTalk
    ../../UAVTalk/: uavtalk.c
    ../../UAVObjects/: uavobjectmanager.c eventdispatcher.c
  group PIOS
    ../../../PiOS/STM32F4xx/: pios_adc.c pios_bl_helper.c pios_debug.c pios_delay.c pios_dsm.c pios_exti.c pios_flash_internal.c pios_gpio.c pios_i2c.c pios_iap.c pios_irq.c pios_led.c pios_overo.c pios_ppm.c pios_pwm.c pios_rtc.c pios_servo.c pios_spi.c pios_sys.c pios_tim.c pios_usart.c pios_usb.c pios_usb_cdc.c pios_usb_hid.c pios_usbhook.c pios_wdg.c startup.c vectors_stm32f4xx.c
  group STM32F4xx
    ../../../PiOS/STM32F4xx/Libraries/CMSIS3/Device/ST/STM32F4xx/Source/flyingf4x/: system_stm32f4xx.c
    ../../../PiOS/STM32F4xx/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group STM32F4xx USB
    ../../../PiOS/STM32F4xx/Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../../../PiOS/STM32F4xx/Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group Common
    ../../../PiOS/Common/: pios_mpu6050.c pios_gcsrcvr.c pios_hmc5883.c pios_ms5611.c pios_crc.c pios_com.c pios_rcvr.c pios_sbus.c pios_sensors.c pios_flash_jedec.c pios_flashfs_logfs.c printf-stdarg.c pios_usb_desc_hid_cdc.c pios_usb_desc_hid_only.c pios_usb_util.c
  group uavobject
    ../../../../build/uavobject-synthetics/flight/: accessorydesired.c actuatorcommand.c actuatordesired.c actuatorsettings.c adcrouting.c airspeedactual.c airspeedsettings.c inssettings.c attitudeactual.c gyros.c gyrosbias.c inertialsensorsettings.c accels.c magnetometer.c magbias.c baroaltitude.c baroairspeed.c altholdsmoothed.c altitudeholddesired.c altitudeholdsettings.c attitudesettings.c attitudesimulated.c cameradesired.c camerastabsettings.c faultsettings.c firmwareiapobj.c fixedwingairspeeds.c fixedwingpathfollowersettings.c fixedwingpathfollowersettingscc.c fixedwingpathfollowerstatus.c flightbatterysettings.c flightbatterystate.c flightplancontrol.c flightplansettings.c flightplanstatus.c flightstatus.c flighttelemetrystats.c gcsreceiver.c gcstelemetrystats.c gpsposition.c gpssatellites.c gpstime.c gpsvelocity.c groundtruth.c homelocation.c hwcoptercontrol.c hwdiscoveryf4.c hwflyingf3.c hwflyingf4.c hwfreedom.c hwosd.c hwquanton.c hwrevolution.c hwrevomini.c i2cstats.c i2cvm.c i2cvmuserprogram.c manualcontrolcommand.c manualcontrolsettings.c mixersettings.c mixerstatus.c modulesettings.c nedaccel.c nedposition.c objectpersistence.c oplinksettings.c oplinkstatus.c osdsettings.c overosyncsettings.c overosyncstats.c pathdesired.c pathplannersettings.c pathstatus.c positionactual.c ratedesired.c receiveractivity.c relaytuning.c relaytuningsettings.c revocalibration.c revosettings.c sonaraltitude.c stabilizationdesired.c stabilizationsettings.c systemalarms.c systemsettings.c systemstats.c taskinfo.c txpidsettings.c uavobjectsinit.c velocityactual.c velocitydesired.c vtolpathfollowersettings.c watchdogstatus.c waypoint.c waypointactive.c
  group Config
    ../: UAVObjects.inc
    ../System/inc/: FreeRTOSConfig.h pios_config.h pios_usb_board_data.h
    ./: defs.txt link.txt
    ../../board_hw_defs/flyingf4x/: board_hw_defs.c
